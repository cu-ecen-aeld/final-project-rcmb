## app_external/package/sensors/Config.in
```kconfig
config BR2_PACKAGE_SENSORS
    bool "SENSORS"
    help
        custom package.

        https://test.com
```
